require weston.inc


PACKAGE_ARCH="${MACHINE_ARCH}"

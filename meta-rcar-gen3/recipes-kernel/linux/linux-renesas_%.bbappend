FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_ulcb = " \
    file://9999-perf-libbft-upstream.patch \
"

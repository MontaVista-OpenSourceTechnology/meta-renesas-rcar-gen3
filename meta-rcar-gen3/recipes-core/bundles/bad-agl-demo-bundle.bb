require agl-demo-bundle.bb

inherit distro_features_check

REQUIRED_DISTRO_FEATURES = "bad-bundle"

COMPATIBLE_MACHINE = "r8a7795|r8a7796"

SRCREV = "7f156a6064c11b4e623347fd7d0141ecee75eb36"

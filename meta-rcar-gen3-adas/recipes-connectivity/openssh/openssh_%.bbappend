
PACKAGES =+ " ${PN}-sftp-server-dev"
FILES_${PN}-sftp-server-dev = ""

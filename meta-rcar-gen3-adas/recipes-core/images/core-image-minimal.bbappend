IMAGE_INSTALL_append = " \
    packagegroup-opencv-sdk \
    packagegroup-surroundview-drm \
    utest-cam-imr-drm \
"

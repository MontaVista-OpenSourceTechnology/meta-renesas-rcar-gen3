IMAGE_INSTALL_append = " \
    packagegroup-opencv-sdk \
    packagegroup-surroundview \
    utest-cam-imr-drm \
"

CONFLICT_DISTRO_FEATURES = "x11"